############################################################################
##
## This file is part of the Ecosysteme meta layer.
##
############################################################################

DESCRIPTION = "SDK toolchain for the Ecosysteme image"

