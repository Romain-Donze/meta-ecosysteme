############################################################################
##
## This file is part of the Ecosysteme meta layer.
##
############################################################################

SUMMARY = "Image for the Ecosysteme"

IMAGE_INSTALL += "\
    can-utils \
    libsocketcan \
    udev-extraconf \
    "
